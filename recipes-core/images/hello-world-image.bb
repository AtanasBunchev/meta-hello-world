include recipes-core/images/core-image-base.bb

IMAGE_INSTALL:append = " hello-world vim"
